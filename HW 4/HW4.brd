# Repository ve73f/ME433

## EAGLE design HW 4/HW4.brd

Parts:
C2, C3: 0.1uF; C025-024X044
C4: 10uF; C025-024X044
LED1RED, LED2GREEN: LED3MM
R1, R2: 330; 0207/7
R3, R4: 10k; 0207/7
U$1: PIC32; DIL28-3
U$2: BAT
U$3: SLIDE
U$4: VREG
U$5: USBTOUART
U$6: SNAP
U$7: DISPLAY
U$8: RESET; BUTTON
U$9: USER; BUTTON
U$10, U$11, U$16, U$17, U$18: ONE
U$12, U$13, U$14, U$15: FIVE

Connections:
+3V3: C2.1, C3.1, LED1RED.A, R3.2, R4.2, U$1.13 (13.VDD), U$1.28 (28.AVDD), U$4.1 (1.VOUT), U$6.2 (2.VDD), U$7.2 (2.VCC), U$13.4, U$14.3, U$17.P$1
+5V: U$3.3 (3.IN), U$3.4 (4.IN), U$5.3 (3.5V)
A0: U$1.2 (2.A0), U$15.1
A1: U$1.3 (3.A1), U$15.2
A3: U$1.10 (10.A3), U$15.4
A4: LED2GREEN.A, U$1.12 (12.A4/LED)
B2: U$1.6 (6.B2), U$15.3
B4: R4.1, U$1.11 (11.B4/USER), U$9.1
B5: U$1.14 (14.B5), U$15.5
B6: U$1.15 (15.B6), U$14.1
B7: U$1.16 (16.B7), U$13.2
B10: U$1.21 (21.B10/U2TX), U$13.1
B11: U$1.22 (22.B11/U2RX), U$12.5
B12: U$1.23 (23.B12), U$12.4
B13: U$1.24 (24.B13/OC5), U$12.3
B14: U$1.25 (25.B14/OC3), U$12.2
B15: U$1.26 (26.B15/OC1), U$12.1
GND: C2.2, C3.2, C4.2, R1.1, R2.1, U$1.8 (8.VSS), U$1.19 (19.VSS), U$1.27 (27.AVSS), U$2.1 (1.GND), U$4.2 (2.GND), U$5.1 (1.GND), U$6.3 (3.GND), U$7.1 (1.GND), U$8.2, U$9.2, U$13.5, U$14.4, U$14.5, U$18.P$1
MCLR: R3.1, U$1.1 (1.MCLR), U$6.1 (1.MCLR), U$8.1
unnamed: LED1RED.K (C), R1.2
unnamed: LED2GREEN.K (C), R2.2
unnamed: U$2.2 (2.VBAT), U$3.1 (1.IN), U$3.6 (6.IN)
unnamed: U$3.2 (2.OUT), U$3.5 (5.OUT), U$4.3 (3.VIN)
unnamed: C4.1, U$1.20 (20.VCAP)
PGC: U$1.5 (5.B1/PGC), U$6.5 (5.PGC)
PGD: U$1.4 (4.B0/PGD), U$6.4 (4.PGD)
SCL: U$1.17 (17.B8/SCL1), U$7.3 (3.SCL), U$11.P$1
SDA: U$1.18 (18.B9/SDA1), U$7.4 (4.SDA), U$10.P$1
U1RX: U$1.9 (9.A2/U1RX), U$5.4 (4.TXD)
U1TX: U$1.7 (7.B3/U1TX), U$5.5 (5.RXD)
VIN: U$13.3, U$14.2, U$16.P$1

Board: 2 copper layers, 50.0 x 50.0 mm, 27 parts (0 on the bottom side), 31 nets.

## Commit log

2022-06-08 HW 6
2022-06-08 HW 8
2022-06-08 HW 10
2022-06-08 HW 11
2022-06-09 HW 4
2022-06-09 HW 12
2022-06-11 HW12
2022-06-11 HW 9
